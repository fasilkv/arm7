# Keil uVision project smartwatch.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: armi2c +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group application
    ./: Startup.s main_interup.c oled_window.c main.c main_i2c.c main_rtc.c header.h
  group driver
    ./: gpio_driver.c timer0_delay.c uart_driver.c i2c_driver.c oled_driver.c ext_interrupt.c rtc_driver.c
